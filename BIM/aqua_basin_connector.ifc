Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: aqua_basin_connector.ifc
Time: 2021-08-04T22:31:35
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: AQUA Basin connector
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): AQUA Basin connector; SKU (BO_prodsku): 506401614; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): Faucet complements; ProductGroup (BO_prodgroup): Aqua; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 10/1/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 255; Height (BO_height): 65; Depth (BO_depth): 115; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/506401614; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/506401614; ProductUrl (BO_producturl): http://www.export.roca.com/roca-web/catalog-product-detail?codeProduct=506401614; TechnicalDescription (BO_techcert): http://www.export.roca.com/roca-services/productSheet/EX/en/506401614/; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Chrome; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Taps & Mixers; BimObjectCategoryCode (BO_bocat_code): sanitary-taps-mixers; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass14Code (BO_uniclass_1_4_code): L725111; Uniclass14Description (BO_uniclass_1_4_desc): Mixer taps; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
